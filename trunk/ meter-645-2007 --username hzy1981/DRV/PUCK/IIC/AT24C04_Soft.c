#include "DrvPub.h"

        //�����һ·IC epprom
#ifdef ID_MEM_24C04
/**********************************************************************************/
/**********************************************************************************/ 
void Set_04_Sclk_Dir(INT8U Dir)
{
  if(Dir==DIR_OUTPUT)
    SET_04_SCLK_OUTPUT;
  else
    SET_04_SCLK_INPUT;  
}
/**********************************************************************************
**********************************************************************************/ 
void Set_04_Sda_Dir(INT8U Dir)
{
  if(Dir==DIR_OUTPUT)
    SET_04_SDA_OUTPUT;
  else
    SET_04_SDA_INPUT; 
}
/**********************************************************************************
**********************************************************************************/ 
void Set_04_Sclk_Pin(INT8U Level)
{
  if(Level)
    SET_04_SCLK_1; 
  else
    CLR_04_SCLK_0; 
}
/**********************************************************************************
**********************************************************************************/ 
void Set_04_Sda_Pin(INT8U Level)
{
  if(Level)
    SET_04_SDA_1; 
  else
    CLR_04_SDA_0; 
}
/**********************************************************************************
**********************************************************************************/ 
INT8U Get_04_Sda_Pin(void)
{
  return (GET_04_STATUS);  
}
#endif

# IAR project Meter_New645.ewp, settings and files
configuration Debug (78000, debug)
  General.GHeapSize: 256
  General.GFarHeapSize: 0
  General.GeneralDeviceSelect: 78F1166_A0 78K0R - uPD78F1166_A0
  ICC78000.CCIncludePath2: ..\..\UOS\SRC\; ..\..\UOS\PORT\78K\; ..\..\APP\CFG\H\; ..\..\APP\TASK\H\; ..\..\APP\PUB\H\; ..\..\APP\HUCK\Clock\H\; ..\..\APP\HUCK\Control\H\; ..\..\APP\HUCK\Energy\H\; ..\..\APP\HUCK\EventData\H\; ..\..\APP\HUCK\LoadData\H\; ..\..\APP\HUCK\LowPower\H\; ..\..\APP\HUCK\Monitor\H\; ..\..\APP\HUCK\Storage\H\; ..\..\APP\HUCK\Protocol\H\; ..\..\APP\HUCK\VolStat\H\; ..\..\APP\HUCK\Demand\H\; ..\..\APP\HUCK\Freeze\H\; ..\..\APP\HUCK\Extend\H\; ..\..\TEST\PUB_T\H\; ..\..\HAL\H\; ..\..\APP\PUCK\Private\MeasuProc\h; ..\..\APP\PUCK\Private\Alarm; ..\..\APP\PUCK\Private\\ICcard; ..\..\APP\PUCK\Private\EventProc\h; ..\..\APP\PUCK\Private\Channel\h; ..\..\APP\PUCK\Private\Remoter; ..\..\APP\LUCK\h; ..\..\APP\PUCK\Public\h; ..\..\ABS\PUCK\; ..\..\ABS\QUCK\H; ..\..\DRV\PUB; ..\..\DRV\SUCK\; ..\..\DRV\PUCK\LCD; ..\..\DRV\PUCK\ICCARD; ..\..\DRV\PUCK\IIC; ..\..\DRV\PUCK\LVI; ..\..\DRV\PUCK\BUZ; ..\..\DRV\PUCK\WDT; ..\..\DRV\PUCK\RTC; ..\..\DRV\PUCK\UART; ..\..\DRV\PUCK\PAY; ..\..\DRV\PUCK\PAY\ESAM; ..\..\DRV\PUCK\PAY\CPU_CARD; ..\..\TEST\PUCK\DRV_TEST
  ICC78000.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC78000.CCOptLevel: 3
  ICC78000.CCOptStrategy: 1
  A78000.ADefines: __FAR_MODEL__; __FAR_DATA_MODEL__
  A78000.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk78f1166_a0.xcl
  XLINK.XlinkStackSize: 1
configuration Release (78000)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC78000.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group ABS/PUCK/CPU_ESAM
    ../../ABS/PUCK/: CpuEsamAbs.c CpuEsamAbs.h
  group ABS/PUCK/DEVICE
    ../../ABS/PUCK/: DeviceAbs.c DeviceAbs.h
  group ABS/PUCK/INTERR
    ../../ABS/PUCK/: InterrAbs.c InterrAbs.h
  group ABS/PUCK/MEM
    ../../ABS/PUCK/: MemoryAbs.c MemoryAbs.h
  group ABS/PUCK/PORT
    ../../ABS/PUCK/: PortAbs.c PortAbs.h
  group ABS/PUCK/RTC
    ../../ABS/PUCK/: RTCAbs.c RTCAbs.h
  group ABS/PUCK/UART
    ../../ABS/PUCK/: UartAbs.c UartAbs.h
  group ABS/QUCK/CpuCard/PasswordCard
    ../../ABS/QUCK/H/: Ctrl_Code_0x14_SetData.c Ctrl_Code_0x14_SetData.h Far_Deal_Ctrl_0x03.c Far_Deal_Ctrl_0x03.h FarDef.h
  group ABS/QUCK/CpuCard/ReadEsamCard
    ../../ABS/QUCK/H/: Cpucard_Driver.c Cpucard_Driver.h CpucardBase.c CpucardBase.h
  group ABS/QUCK/CpuCard/RelayTestCard
    ../../ABS/QUCK/H/: BuyCard.c BuyCard.h pay_def.h
  group ABS/QUCK/CpuCard/UserCard
    ../../ABS/QUCK/H/: AllCardOperation.c AllCardOperation.h AllCardOperationDef.h MyIncludesAll.h
  group APP/CFG
    ../../APP/Cfg/H/: Meter_Cfg.h
    ../../APP/Cfg/C/: Meter_License.c
  group APP/HUCK/CLOCK
    ../../APP/HUCK/Clock/C/: Clock.c Clock_Proto.c
    ../../APP/HUCK/Clock/H/: Clock.h Clock_Proto.h
  group APP/HUCK/CONTROL
    ../../APP/HUCK/Control/C/: Power_Ctrl.c
    ../../APP/HUCK/Control/H/: Power_Ctrl.h
  group APP/HUCK/DEMAND
    ../../APP/HUCK/Demand/C/: Demand.c Demand_Proto.c Demand_Settle.c
    ../../APP/HUCK/Demand/H/: Demand.h Demand_Proto.h Demand_Settle.h
  group APP/HUCK/ENERGY
    ../../APP/HUCK/Energy/C/: Energy.c Energy_Proto.c Energy_Settle.c Energy_Task.c Prepaid.c
    ../../APP/HUCK/Energy/H/: Energy.h Energy_Proto.h Energy_Settle.h Energy_Task.h Prepaid.h
  group APP/HUCK/EVENTDATA
    ../../APP/HUCK/EventData/C/: Event_Cumu.C Event_Data.c Event_Proto.c Event_Separate.C
    ../../APP/HUCK/EventData/H/: Event_Cumu.h Event_Data.h Event_Proto.h Event_Separate.h
  group APP/HUCK/EXTEND
    ../../APP/HUCK/Extend/C/: Extend.c
    ../../APP/HUCK/Extend/H/: Extend.h
  group APP/HUCK/FREEZE
    ../../APP/HUCK/Freeze/C/: Freeze_Data.c Freeze_Proto.c
    ../../APP/HUCK/Freeze/H/: Freeze_Data.h Freeze_Proto.h
  group APP/HUCK/LOADDATA
    ../../APP/HUCK/LoadData/C/: Load_Data.c
    ../../APP/HUCK/LoadData/H/: Load_Data.h
  group APP/HUCK/LOWPOWER
    ../../APP/HUCK/LowPower/C/: Low_Power.c
    ../../APP/HUCK/LowPower/H/: Low_Power.h
  group APP/HUCK/MONITOR
    ../../APP/HUCK/Monitor/C/: Sys_Monitor.c
    ../../APP/HUCK/Monitor/H/: Sys_Monitor.h
  group APP/HUCK/PROTOCOL
    ../../APP/HUCK/Protocol/C/: Authority.c Data_Trans.c
    ../../APP/HUCK/Protocol/H/: Authority.h Data_Trans.h Proto_DI.h
  group APP/HUCK/STORAGE
    ../../APP/HUCK/Storage/C/: Data_Para.c Def_Para.c Sys_Memory.c
    ../../APP/HUCK/Storage/H/: Data_Para.h Def_Para.h Mem_Cfg.h Sys_Memory.h
  group APP/HUCK/VOLSTAT
    ../../APP/HUCK/VolStat/C/: VolStat.c VolStat_Proto.c VolStat_Settle.c
    ../../APP/HUCK/VolStat/H/: VolStat.h VolStat_Proto.h VolStat_Settle.h
  group APP/LUCK/BASIC
    ../../APP/LUCK/C/: BaseDis.c interface.c Lcd_main_LUCK.c process.c support.c
    ../../APP/LUCK/H/: BaseDis.h config.h interface.h Lcd_main_LUCK.h process.h support.h
  group APP/LUCK/CAL_METER
    ../../APP/LUCK/C/: Cal_Dis.c
    ../../APP/LUCK/H/: Cal_Dis.h
  group APP/LUCK/LCD
    ../../APP/LUCK/C/: interface_EASY_GZL.c interface_GW_ZXW.c interface_JS_ZXW.c interface_SD_ZXW.c
  group APP/MAIN
    ../../APP/Main/C/: Main_Proc.c
  group APP/PUB
    ../../APP/Pub/H/: Includes.h Pub.h Pub_Debug.h Pub_Err.h Pub_Sem.h Pub_Shell.h Pub_Time.h
    ../../APP/Pub/C/: Pub.c Pub_Debug.c Pub_Shell.c Pub_Time.c
  group APP/PUCK/PRIVATE/ALARM
    ../../APP/PUCK/Private/Alarm/: Alarm.c Alarm.h
  group APP/PUCK/PRIVATE/CAL_METER
    ../../APP/PUCK/Private/MeasuProc/c/: MeasuCal.c
    ../../APP/PUCK/Private/MeasuProc/h/: MeasuCal.h
  group APP/PUCK/PRIVATE/CHANNEL
    ../../APP/PUCK/Private/Channel/c/: Channel.c
    ../../APP/PUCK/Private/Channel/h/: Channel.h
  group APP/PUCK/PRIVATE/EVENT
    ../../APP/PUCK/Private/EventProc/c/: EventInstant.c EventPub.c EventStatus.c
    ../../APP/PUCK/Private/EventProc/h/: EventInstant.h EventPub.h EventStatus.h
  group APP/PUCK/PRIVATE/MEASURE
    ../../APP/PUCK/Private/MeasuProc/c/: AllLossVolt.c MeasuBase.c MeasuLib.c MeasuPara.c MeasuPort.c MeasuProc.c MeasuPulse.c
    ../../APP/PUCK/Private/MeasuProc/h/: AllLossVolt.h MeasuBase.h MeasuLib.h MeasuPara.h MeasuPort.h MeasuProc.h MeasuPulse.h
  group APP/PUCK/PRIVATE/REMOTE
    ../../APP/PUCK/Private/Remoter/: Remoter.c Remoter.h
  group APP/PUCK/PUBLIC
    ../../APP/PUCK/Public/H/: App_Cfg_PUCK.h Include_PUCK.h Pub_Puck.h
    ../../APP/PUCK/Public/C/: Pub_PUCK.c
  group APP/TASK
    ../../APP/TASK/C/: TaskProc.c
    ../../APP/TASK/H/: TaskProc.h
  group DRV/PUB
    ../../DRV/PUB/: CPUPub.c CPUPub.h DrvCfg.h DrvPub.c DrvPub.h
  group DRV/PUCK/BUZ
    ../../DRV/PUCK/BUZ/: PCLBUZ.c PCLBUZ.h
  group DRV/PUCK/IIC/APP
    ../../DRV/PUCK/IIC/: App_Epp_All.c App_Epp_All.h App_RTC_All.c App_RTC_All.h
  group DRV/PUCK/IIC/CPU
    ../../DRV/PUCK/IIC/: I2C_Soft.c I2C_Soft.h IIC0_Hard.c IIC0_Hard.h
  group DRV/PUCK/IIC/DRV
    ../../DRV/PUCK/IIC/: Epp_Hard.c Epp_Hard.h Epp_Soft.c Epp_Soft.h
  group DRV/PUCK/IIC/IC
    ../../DRV/PUCK/IIC/: AT24C04_Soft.c AT24C04_Soft.h BL55076_Soft.c BL55076_Soft.h DS3231_Hard.c DS3231_Hard.h DS3231_Soft.c DS3231_soft.h FM24C16_Soft.c FM24C16_Soft.h RX8025_Soft.c RX8025_Soft.h RX8025T_Soft.c RX8025T_Soft.h
  group DRV/PUCK/INTER
    ../../DRV/SUCK/: Int.c Int.h Int_user.c
  group DRV/PUCK/IO
    ../../DRV/SUCK/: Port.c port.h user_define.h
  group DRV/PUCK/LCD/APP
    ../../DRV/PUCK/LCD/: APP_ALL_LCD.h APP_BL55076.C APP_HTLCD.C
  group DRV/PUCK/LCD/LIB
    ../../DRV/PUCK/LCD/: APP_LCD_LIB_GZL.h APP_LCD_Pub.h APP_LCD_Pub_GW_ZXW.h APP_LCD_Pub_JS_ZXW.h APP_LCD_Pub_SD_ZXW.h BLLCD_LIB_GZL.h HTLCD_LIB.h HTLCD_LIB_GW_ZXW.h HTLCD_LIB_JS_ZXW.h HTLCD_LIB_SD_ZXW.h
  group DRV/PUCK/LCD/PUB
    ../../DRV/PUCK/LCD/: LCD_CFG.h
  group DRV/PUCK/LVI
    ../../DRV/PUCK/LVI/: LVI.c LVI.h
  group DRV/PUCK/PAY/CPU_CARD
    ../../DRV/PUCK/PAY/CPU_CARD/: CPU_CARD_DRV.c CPU_CARD_DRV.h
  group DRV/PUCK/PAY/ESAM
    ../../DRV/PUCK/PAY/ESAM/: ESAM_DRV.c ESAM_DRV.h
  group DRV/PUCK/PAY/PUB
    ../../DRV/PUCK/PAY/: PAY_PUB_DRV.c Pay_Pub_Drv.h
  group DRV/PUCK/RTC
    ../../DRV/PUCK/RTC/: RTC.c RTC.h RTC_user.c
  group DRV/PUCK/SYSTEM
    ../../DRV/SUCK/: System.c System.h systeminit.c
  group DRV/PUCK/TAU
    ../../DRV/SUCK/: TAU.c TAU.h TAU_user.c
  group DRV/PUCK/UART
    ../../DRV/PUCK/UART/: Serial.c Serial.h Serial_user.c
  group DRV/PUCK/WDT
    ../../DRV/PUCK/WDT/: WatchdogTimer.c WatchdogTimer.h WatchdogTimer_user.c
  group DRV/SUCK
    ../../DRV/SUCK/: data_flash.c data_flash.h macrodriver.h
  group TEST/HUCK_T
    ../../TEST/HUCK_T/C/: Test_Data_Trans.c Test_Energy_Settle.c
  group TEST/PUB_T
    ../../TEST/PUB_T/C/: Test_Pub.c Test_Stub.c
    ../../TEST/PUB_T/H/: Test_Pub.h
  group TEST/PUCK
    ../../TEST/PUCK/DRV_TEST/: DRV_TEST.c DRV_TEST.h
  group UOS/PORT
    ../../UOS/PORT/78K/: OS_Port.h
  group UOS/SRC
    ../../UOS/SRC/: OS_Cfg.h OS_Core.h OS_Core.r26 OS_Event.h OS_Event.r26 OS_Ext.h OS_Ext.r26 OS_Includes.h OS_Mutex.h OS_Mutex.r26 OS_Port.r26 OS_Pub.h OS_Pub.r26 OS_Shell.h OS_Shell.r26 OS_Time.h OS_Time.r26
